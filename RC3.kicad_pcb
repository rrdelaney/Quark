# Repository rrdelaney/Quark

File README.md:

Quark
=====

REV Motor Controller

This directory will house all the schematics for the Motor Controller used in our electric cars.

## KiCad design RC3.kicad_pcb

Parts:
C1, C2: 1000u
C3, C4, C9, C10, C11: 1u
C5, C6, C7, C8, C12: 47n
D1, D2, D3: DIODE
P1, P4: CONN_2
P2: CONN_3
P3: CONN_3X2
Q1, Q2, Q3, Q4, Q5, Q6, Q7, Q8, Q9, Q10, Q11, Q12, Q13, Q14, Q15, Q16, Q17, Q18: MOSFET_N
R1, R2, R3, R4, R5, R6, R7, R8, R9, R10, R11, R12, R13, R15, R16, R17, R18, R19, R20: 10K
R14: 100K
U1: A4915

Connections:
+5V: C11.1, C12.1, P4.1, R13.2, U1.19 (SPEED), U1.21 (VDD)
+48V: C1.1, C2.1, C3.1, C4.1, C5.1, P1.1, Q2.D, Q4.D, Q6.D, Q8.D, Q10.D, Q12.D, Q14.D, Q16.D, Q18.D, U1.18 (VBB)
DIREC: P3.5, R19.1, U1.24 (DIR)
ESTOPn: P3.3, R18.1, U1.25 (BRAKEn)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C10.1, C11.2, C12.2, D1.1, D2.1, D3.1, P1.2 (PM), P4.2 (PM), Q1.S, Q3.S, Q5.S, Q7.S, Q9.S, Q11.S, Q13.S, Q15.S, Q17.S, R1.1, R2.1, R3.1, R14.2, R15.2, R16.2, R17.2, R18.2, R19.2, R20.2, U1.1 (LSS), U1.17 (GND)
HALL_A: P3.2, R17.1, U1.26 (HA)
HALL_B: P3.4, R16.1, U1.27 (HB)
HALL_C: P3.6, R15.1, U1.28 (HC)
unnamed: Q4.G, Q10.G, Q16.G, R6.1, R7.1
unnamed: R11.2, U1.6 (GLB)
unnamed: R10.2, U1.2 (GLC)
unnamed: Q3.G, Q9.G, Q15.G, R2.2, R11.1
unnamed: C7.1, U1.9 (CB)
unnamed: R6.2, U1.7 (GHB)
unnamed: R12.2, U1.10 (GLA)
unnamed: Q6.G, Q12.G, Q18.G, R8.1, R9.1
unnamed: Q5.G, Q11.G, Q17.G, R3.2, R12.1
unnamed: C8.1, U1.13 (CA)
unnamed: C10.2, U1.14 (VREG)
unnamed: Q1.G, Q7.G, Q13.G, R1.2, R10.1
unnamed: Q2.G, Q8.G, Q14.G, R4.1, R5.1
unnamed: C6.1, U1.5 (CC)
unnamed: R8.2, U1.11 (GHA)
unnamed: R4.2, U1.3 (GHC)
unnamed: R14.1, U1.20 (TDEAD)
unnamed: R13.1, U1.22 (FAULT)
unnamed: C9.1, U1.15 (CP2)
unnamed: C9.2, U1.16 (CP1)
OUT_A: C8.2, D3.2, P2.1, Q5.D, Q6.S, Q11.D, Q12.S, Q17.D, Q18.S, R9.2, U1.12 (SA)
OUT_B: C7.2, D2.2, P2.2 (PM), Q3.D, Q4.S, Q9.D, Q10.S, Q15.D, Q16.S, R7.2, U1.8 (SB)
OUT_C: C6.2, D1.2, P2.3, Q1.D, Q2.S, Q7.D, Q8.S, Q13.D, Q14.S, R5.2, U1.4 (SC)
PWM: P3.1, R20.1, U1.23 (ENABLE)

Board: 2 copper layers, 84.8 x 91.4 mm, 58 parts (0 on the bottom side), 32 nets.

## Commit log

2014-09-07 Added what we have from RC3
2014-09-13 Updated the README.md
    Added more detail.
2014-09-22 Rearranged the library files
2014-09-22 Changed gitignore to allow all .lib files in lib/
2014-09-22 Removed useless files
2014-09-25 Fixed VReg Capacitor
    Changed PCB, schematic and netlist to reflect changes
2014-10-02 Temporary Blinker Circuit
    Still needs work. Will be continued next week.
2014-10-02 Revert "Temporary Blinker Circuit"
    This reverts commit 047dada95ee1cdaacd06e23224845e97d2a0dc1b.
2014-11-17 Added flyback diodes and heatskinks
    All legs of the motor controller now have flyback diodes and FETs are
    now arranged in a manner that heat sinks can be applied. All inputs also
    have pull-down resistors and the 5 VDC has filtering capacitors
2014-11-21 Modified PCB to have mounting holes and keep out
2014-11-21 Revert "Revert "Temporary Blinker Circuit""
    This reverts commit ba742b5cfae837158028333592c9d40cb0f01dda.
2014-11-21 fucked up merging new-lib
2014-11-21 Extended the keepout zone and added 4th hole
2014-12-22 Update LICENSE
